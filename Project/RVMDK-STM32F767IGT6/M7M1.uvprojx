# Keil uVision project M7M1.uvprojx, settings and files
target M7M1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RME +hex
  BeforeMake: copy.bat
  c flags: Optim=1 OneElfS=1 v6Lang=6 wLevel=3
  c misc: -Dlikely(x)="__builtin_expect(!!(x), 1)" -Dunlikely(x)="__builtin_expect(!!(x), 0)"
  c include: ..\..\MEukaron\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\MEukaron\Include\Platform\A7M\Chips\STM32F767IG\rme_platform_STM32F767IG.sct
  link misc: --keep=M7M2_Init --keep=VM* --keep=rtthread
  group Kernel
    ../../MEukaron/Kernel/: rme_kernel.c
  group Platform
    ../../MEukaron/Platform/A7M/: rme_platform_a7m.c rme_platform_a7m_asm.s
  group User
    ../../../M7M2_MuAmmonite/Project/RVMDK-STM32F767IG/Debug/Output/: M7M2_Init.c
    ../../../M5P1_MuProkaron/Project/RVMDK-STM32F767IGT6-RVM/Debug/Output/: VM1.c
    ../../../M5P1(R)_RT-Thread/RVM/rt-thread/bsp/stm32f767-alientek-rvm/: rtthread.c
    ../../../M5P1_MuProkaron/Project/RVMDK-STM32F767IGT6-RVM-DUKTAPE/Debug/Output/: VM_DUKTAPE.c
    ../../../M5P1_MuProkaron/Project/RVMDK-STM32F767IGT6-RVM-LUA/Debug/Output/: VM_LUA.c
  group Linker
    ../../MEukaron/Include/Platform/A7M/Chips/STM32F767IG/: rme_platform_STM32F767IG.sct
