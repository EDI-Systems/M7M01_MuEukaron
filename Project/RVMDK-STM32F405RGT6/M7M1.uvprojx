# Keil uVision project M7M1.uvprojx, settings and files
target M7M1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RME +hex
  BeforeMake: copy.bat
  c flags: Optim=1 OneElfS=1 v6Lang=6 wLevel=3
  c misc: -Dlikely(x)="__builtin_expect(!!(x), 1)" -Dunlikely(x)="__builtin_expect(!!(x), 0)"
  c include: ..\..\MEukaron\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\MEukaron\Include\Platform\A7M\Chips\STM32F405RG\rme_platform_STM32F405RG.sct
  link misc: --keep=M7M2_Init
  group Kernel
    ../../MEukaron/Kernel/: rme_kernel.c
  group Platform
    ../../MEukaron/Platform/A7M/: rme_platform_a7m.c rme_platform_a7m_asm.s
